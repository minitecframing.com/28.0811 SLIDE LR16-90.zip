# Autodesk Inventor assembly: 28.0815 END CAP LR 16
## iProperties
Created: 2009-01
Part Number: 28.0815 END CAP LR 16
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
