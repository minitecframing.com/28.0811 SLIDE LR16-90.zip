# Autodesk Inventor assembly: 28.0811 SLIDE LR16-90
## iProperties
Created: 2009-01
Part Number: 28.0811 SLIDE LR16-90
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
